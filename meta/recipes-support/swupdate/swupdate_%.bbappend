FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

# ubi support etc depends on the MACHINE
PACKAGE_ARCH = "${MACHINE_ARCH}"
