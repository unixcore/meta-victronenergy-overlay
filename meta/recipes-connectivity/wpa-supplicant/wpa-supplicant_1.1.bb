require wpa-supplicant.inc

PR = "r0"

SRC_URI[md5sum] = "b29b9af02d7e092db8c5c8508de0e45c"
SRC_URI[sha256sum] = "a54dbe5cfd47b724d7433366d536f76bbc31efea2df866a8f2f87c86a48b9e02"
