RDEPENDS_${PN} = "python-email python-json python-netserver python-zlib"
